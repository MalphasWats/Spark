# Repository MalphasWats/Spark

## KiCad design Spark.kicad_pcb

Parts:
C0: 0.1uF; C_0402_1005Metric
C1: C_Small; C_0402_1005Metric
C2, C3: 12pF; C_0402_1005Metric
D0, D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59: LED_ALT; LED_0402-Clean
J0: Battery Pads; BatteryHolder_Keystone_3002_1x2032
J1: ISP-PROG-6; ISP_SMD
R0, R1, R2, R3, R4: 220R; R_0402_1005Metric
SW1: UP; Panasonic_EVQPUK_EVQPUB
SW2: OK; Panasonic_EVQPUK_EVQPUB
SW3: DOWN; Panasonic_EVQPUK_EVQPUB
U0: ATmega1284P-AU; TQFP-44_10x10mm_P0.8mm
U1: BMA280; LGA-12_2x2mm_P0.5mm
Y1: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+BATT: C0.2, C1.1, J0.1, J1.2 (VCC), U0.5 (VCC), U0.17 (VCC), U0.27 (AVCC), U0.29 (AREF), U0.38 (VCC), U1.3 (VddIO), U1.7 (Vdd)
ACC_INT: U0.31 (PA6), U1.5 (INT1)
BAT_MON: U0.30 (PA7)
CS: U0.44 (PB4), U1.10 (~CSB)
EIGHT: D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), U0.41 (PB1)
ELEVEN: D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), U0.22 (PC3)
FIVE: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), U0.11 (PD2)
FOUR: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U0.12 (PD3)
GND: C0.1, C1.2, C2.2, C3.2, J0.2, J1.6 (GND), SW1.1, SW2.1, SW3.1, U0.6 (GND), U0.18 (GND), U0.28 (GND), U0.39 (GND), U1.4 (GND), U1.8 (GNDIO), U1.9 (GND), U1.11 (PS)
HOUR: D0.2 (A), D5.2 (A), D10.2 (A), D15.2 (A), D20.2 (A), D25.2 (A), D30.2 (A), D35.2 (A), D40.2 (A), D45.2 (A), D50.2 (A), D55.2 (A), R0.2
M1: D1.2 (A), D6.2 (A), D11.2 (A), D16.2 (A), D21.2 (A), D26.2 (A), D31.2 (A), D36.2 (A), D41.2 (A), D46.2 (A), D51.2 (A), D56.2 (A), R1.2
M2: D2.2 (A), D7.2 (A), D12.2 (A), D17.2 (A), D22.2 (A), D27.2 (A), D32.2 (A), D37.2 (A), D42.2 (A), D47.2 (A), D52.2 (A), D57.2 (A), R2.2
M3: D3.2 (A), D8.2 (A), D13.2 (A), D18.2 (A), D23.2 (A), D28.2 (A), D33.2 (A), D38.2 (A), D43.2 (A), D48.2 (A), D53.2 (A), D58.2 (A), R3.2
M4: D4.2 (A), D9.2 (A), D14.2 (A), D19.2 (A), D24.2 (A), D29.2 (A), D34.2 (A), D39.2 (A), D44.2 (A), D49.2 (A), D54.2 (A), D59.2 (A), R4.2
MISO: J1.1 (MISO), U0.2 (PB6), U1.1 (SDO)
MOSI: J1.4 (MOSI), U0.1 (PB5), U1.2 (SDx)
NINE: D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), U0.33 (PA4)
unnamed: R0.1, U0.34 (PA3)
unnamed: R1.1, U0.35 (PA2)
unnamed: R2.1, U0.36 (PA1)
unnamed: R3.1, U0.37 (PA0)
unnamed: R4.1, U0.40 (PB0)
unnamed: SW1.2, U0.16 (PD7)
unnamed: SW2.2, U0.13 (PD4)
unnamed: SW3.2, U0.15 (PD6)
ONE: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), U0.20 (PC1)
RESET: J1.5 (~RESET), U0.4 (~RESET)
SCK: J1.3 (SCK), U0.3 (PB7), U1.12 (SCx)
SEVEN: D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), U0.42 (PB2)
SIX: D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), U0.43 (PB3)
TEN: D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), U0.32 (PA5)
THREE: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), U0.14 (PD5)
TOSC1: C2.1, U0.25 (PC6), Y1.2
TOSC2: C3.1, U0.26 (PC7), Y1.1
TWELVE: D0.1 (K), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), U0.21 (PC2)
TWO: D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U0.19 (PC0)

Board: 4 copper layers, 36.0 x 36.0 mm, 77 parts (5 on the bottom side), 35 nets.

## KiCad design dial/dial.kicad_pcb

Parts:
C0: 0.1uF; C_0402_1005Metric
C1: C_Small; C_0402_1005Metric
C2, C3: 12pF; C_0402_1005Metric
C4, C5, C6: 1uF; C_0402_1005Metric
C7, C8: 4.7uF; C_0402_1005Metric
D0, D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59: LED_ALT; LED_0402-Clean
J0: Battery Pads; 150mAh-Lipo
J1: SWD-PROG-6; ISP_SMD
R0, R1, R2, R3, R4: 220R; R_0402_1005Metric
R5, R6: 10M; R_0402_1005Metric
R7: 2K; R_0402_1005Metric
SW1: UP; Panasonic_EVQPUK_EVQPUB
SW2: OK; Panasonic_EVQPUK_EVQPUB
SW3: DOWN; Panasonic_EVQPUK_EVQPUB
U0: ATSAMD21G18A-AUT; TQFP-48_7x7mm_P0.5mm
U1: BMA250E; LGA-12_2x2mm_P0.5mm
U2: Reg; SOT-23
U3: CHG CTRL; SOT-23-5
Y1: 32.768KHz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
+3V3: C0.2, C1.1, C5.1, U0.6 (VDDANA), U0.17 (VDDIO), U0.36 (VDDIO), U0.43 (VDDCORE), U0.44 (VDDIN), U1.3 (VddIO), U1.7 (Vdd), U2.2 (VO)
+BATT: C4.1, C7.1, J0.1, R5.1, U2.3 (VI), U3.3 (VBAT)
BAT_MON: C6.1, R5.2, R6.1, U0.8 (PB09)
CHARGE: C8.1, J1.2 (VCC), U3.4 (VDD)
CSB: U0.31 (PA22), U1.10 (~CSB)
EIGHT: D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), U0.22 (PA13)
ELEVEN: D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), U0.4 (PA03)
FIVE: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), U0.27 (PA18)
FOUR: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U0.33 (PA24)
GND: C0.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J0.2, J1.6 (GND), R6.2, R7.2, SW1.1, SW2.1, SW3.1, U0.5 (GNDANA), U0.18 (GND), U0.35 (GND), U0.42 (GND), U1.4 (GND), U1.5 (INT1), U1.6 (INT2), U1.8 (GNDIO), U1.9 (GND), U1.11 (PS), U2.1 (GND), U3.2 (VSS)
HOUR: D0.2 (A), D5.2 (A), D10.2 (A), D15.2 (A), D20.2 (A), D25.2 (A), D30.2 (A), D35.2 (A), D40.2 (A), D45.2 (A), D50.2 (A), D55.2 (A), R0.2
M1: D1.2 (A), D6.2 (A), D11.2 (A), D16.2 (A), D21.2 (A), D26.2 (A), D31.2 (A), D36.2 (A), D41.2 (A), D46.2 (A), D51.2 (A), D56.2 (A), R1.2
M2: D2.2 (A), D7.2 (A), D12.2 (A), D17.2 (A), D22.2 (A), D27.2 (A), D32.2 (A), D37.2 (A), D42.2 (A), D47.2 (A), D52.2 (A), D57.2 (A), R2.2
M3: D3.2 (A), D8.2 (A), D13.2 (A), D18.2 (A), D23.2 (A), D28.2 (A), D33.2 (A), D38.2 (A), D43.2 (A), D48.2 (A), D53.2 (A), D58.2 (A), R3.2
M4: D4.2 (A), D9.2 (A), D14.2 (A), D19.2 (A), D24.2 (A), D29.2 (A), D34.2 (A), D39.2 (A), D44.2 (A), D49.2 (A), D54.2 (A), D59.2 (A), R4.2
NINE: D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), U0.12 (PA07)
unnamed: R0.1, U0.13 (PA08)
unnamed: R1.1, U0.14 (PA09)
unnamed: R2.1, U0.15 (PA10)
unnamed: R3.1, U0.16 (PA11)
unnamed: R4.1, U0.21 (PA12)
unnamed: R7.1, U3.5 (PROG)
unnamed: SW1.2, U0.47 (PB02)
unnamed: SW2.2, U0.38 (PB23)
unnamed: SW3.2, U0.37 (PB22)
ONE: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), U0.41 (PA28)
RESET: J1.5 (~nRST), U0.40 (~RESET)
SCx: U0.30 (PA21), U1.12 (SCx)
SDO: U0.29 (PA20), U1.1 (SDO)
SDx: U0.28 (PA19), U1.2 (SDx)
SEVEN: D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), U0.24 (PA15)
SIX: D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), U0.25 (PA16)
SWCLK: J1.3 (SWDCLK), U0.45 (PA30)
SWDIO: J1.1 (SWDIO), U0.46 (PA31)
TEN: D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), U0.10 (PA05)
THREE: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), U0.34 (PA25)
TWELVE: D0.1 (K), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), U0.3 (PA02)
TWO: D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U0.39 (PA27)
XIN: C3.1, U0.1 (PA00), Y1.1
XOUT: C2.1, U0.2 (PA01), Y1.2

Board: 2 copper layers, 36.0 x 36.0 mm, 87 parts (16 on the bottom side), 40 nets.

## KiCad design logic/logic.kicad_pcb

Schematic: logic.sch

Parts:
J0: COLS; PinHeader_1x15_P2.00mm_Vertical
J1: ROWS; PinHeader_1x15_P2.00mm_Vertical
J2: ISP-PROG-6; PinHeader_2x03_P2.54mm_Vertical
U0: ATSAMD21G18A-AUT; TQFP-48_7x7mm_P0.5mm
U1: BMA250E; LGA-12_2x2mm_P0.5mm

Connections:
+3V3: J2.2 (VCC), U0.6, U0.17, U0.36, U0.43, U0.44
COL_0: J0.1, U0.1
COL_1: J0.2, U0.2
COL_2: J0.3, U0.3
COL_3: J0.4, U0.4
COL_4: J0.5, U0.9
COL_5: J0.6, U0.10
COL_6: J0.7, U0.11
COL_7: J0.8, U0.12
COL_8: J0.9, U0.13
COL_9: J0.10, U0.14
COL_10: J0.11, U0.15
COL_11: J0.12, U0.16
COL_12: J0.13, U0.21
COL_13: J0.14, U0.22
COL_14: J0.15, U0.23
GND: J2.6 (GND), U0.5, U0.18, U0.35, U0.42
RESET: J2.5 (~RESET), U0.40
ROW_0: J1.15, U0.24
ROW_1: J1.14, U0.25
ROW_2: J1.13, U0.26
ROW_3: J1.12, U0.27
ROW_4: J1.11, U0.28
ROW_5: J1.10, U0.29
ROW_6: J1.9, U0.30
ROW_7: J1.1, U0.41
ROW_8: J1.2, U0.39
ROW_9: J1.3, U0.38
ROW_10: J1.4, U0.37
ROW_11: J1.5, U0.34
ROW_12: J1.6, U0.33
ROW_13: J1.7, U0.32
ROW_14: J1.8, U0.31
SWCLK: J2.3 (SCK), U0.45
SWDIO: J2.1 (MISO), U0.46

Board: 2 copper layers, 33.0 x 40.0 mm, 5 parts (3 on the bottom side), 35 nets.

## KiCad design matrix/Matrix.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132, D133, D134, D135, D136, D137, D138, D139, D140, D141, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152, D153, D154, D155, D156, D157, D158, D159, D160, D161, D162, D163, D164, D165, D166, D167, D168, D169, D170, D171, D172, D173, D174, D175, D176, D177, D178, D179, D180, D181, D182, D183, D184, D185, D186, D187, D188, D189, D190, D191, D192, D193, D194, D195, D196, D197, D198, D199, D200, D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216, D217, D218, D219, D220, D221, D222, D223, D224, D225: LED_ALT; LED_0402-Clean
J0: COLS; Pin_Header_Straight_1x15_Pitch1.27mm
J1: ROWS; Pin_Header_Straight_1x15_Pitch1.27mm
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15: 1.3k; R_0402_Clean

Connections:
COL_0: J0.1, R1.1
COL_1: J0.2, R2.1
COL_2: J0.3, R3.1
COL_3: J0.4, R4.1
COL_4: J0.5, R5.1
COL_5: J0.6, R6.1
COL_6: J0.7, R7.1
COL_7: J0.8, R8.1
COL_8: J0.9, R9.1
COL_9: J0.10, R10.1
COL_10: J0.11, R11.1
COL_11: J0.12, R12.1
COL_12: J0.13, R13.1
COL_13: J0.14, R14.1
COL_14: J0.15, R15.1
unnamed: D1.1 (K), D16.1 (K), D31.1 (K), D46.1 (K), D61.1 (K), D76.1 (K), D91.1 (K), D106.1 (K), D121.1 (K), D136.1 (K), D151.1 (K), D166.1 (K), D181.1 (K), D196.1 (K), D211.1 (K), R1.2
unnamed: D10.1 (K), D25.1 (K), D40.1 (K), D55.1 (K), D70.1 (K), D85.1 (K), D100.1 (K), D115.1 (K), D130.1 (K), D145.1 (K), D160.1 (K), D175.1 (K), D190.1 (K), D205.1 (K), D220.1 (K), R10.2
unnamed: D11.1 (K), D26.1 (K), D41.1 (K), D56.1 (K), D71.1 (K), D86.1 (K), D101.1 (K), D116.1 (K), D131.1 (K), D146.1 (K), D161.1 (K), D176.1 (K), D191.1 (K), D206.1 (K), D221.1 (K), R11.2
unnamed: D12.1 (K), D27.1 (K), D42.1 (K), D57.1 (K), D72.1 (K), D87.1 (K), D102.1 (K), D117.1 (K), D132.1 (K), D147.1 (K), D162.1 (K), D177.1 (K), D192.1 (K), D207.1 (K), D222.1 (K), R12.2
unnamed: D13.1 (K), D28.1 (K), D43.1 (K), D58.1 (K), D73.1 (K), D88.1 (K), D103.1 (K), D118.1 (K), D133.1 (K), D148.1 (K), D163.1 (K), D178.1 (K), D193.1 (K), D208.1 (K), D223.1 (K), R13.2
unnamed: D14.1 (K), D29.1 (K), D44.1 (K), D59.1 (K), D74.1 (K), D89.1 (K), D104.1 (K), D119.1 (K), D134.1 (K), D149.1 (K), D164.1 (K), D179.1 (K), D194.1 (K), D209.1 (K), D224.1 (K), R14.2
unnamed: D15.1 (K), D30.1 (K), D45.1 (K), D60.1 (K), D75.1 (K), D90.1 (K), D105.1 (K), D120.1 (K), D135.1 (K), D150.1 (K), D165.1 (K), D180.1 (K), D195.1 (K), D210.1 (K), D225.1 (K), R15.2
unnamed: D2.1 (K), D17.1 (K), D32.1 (K), D47.1 (K), D62.1 (K), D77.1 (K), D92.1 (K), D107.1 (K), D122.1 (K), D137.1 (K), D152.1 (K), D167.1 (K), D182.1 (K), D197.1 (K), D212.1 (K), R2.2
unnamed: D3.1 (K), D18.1 (K), D33.1 (K), D48.1 (K), D63.1 (K), D78.1 (K), D93.1 (K), D108.1 (K), D123.1 (K), D138.1 (K), D153.1 (K), D168.1 (K), D183.1 (K), D198.1 (K), D213.1 (K), R3.2
unnamed: D4.1 (K), D19.1 (K), D34.1 (K), D49.1 (K), D64.1 (K), D79.1 (K), D94.1 (K), D109.1 (K), D124.1 (K), D139.1 (K), D154.1 (K), D169.1 (K), D184.1 (K), D199.1 (K), D214.1 (K), R4.2
unnamed: D5.1 (K), D20.1 (K), D35.1 (K), D50.1 (K), D65.1 (K), D80.1 (K), D95.1 (K), D110.1 (K), D125.1 (K), D140.1 (K), D155.1 (K), D170.1 (K), D185.1 (K), D200.1 (K), D215.1 (K), R5.2
unnamed: D6.1 (K), D21.1 (K), D36.1 (K), D51.1 (K), D66.1 (K), D81.1 (K), D96.1 (K), D111.1 (K), D126.1 (K), D141.1 (K), D156.1 (K), D171.1 (K), D186.1 (K), D201.1 (K), D216.1 (K), R6.2
unnamed: D7.1 (K), D22.1 (K), D37.1 (K), D52.1 (K), D67.1 (K), D82.1 (K), D97.1 (K), D112.1 (K), D127.1 (K), D142.1 (K), D157.1 (K), D172.1 (K), D187.1 (K), D202.1 (K), D217.1 (K), R7.2
unnamed: D8.1 (K), D23.1 (K), D38.1 (K), D53.1 (K), D68.1 (K), D83.1 (K), D98.1 (K), D113.1 (K), D128.1 (K), D143.1 (K), D158.1 (K), D173.1 (K), D188.1 (K), D203.1 (K), D218.1 (K), R8.2
unnamed: D9.1 (K), D24.1 (K), D39.1 (K), D54.1 (K), D69.1 (K), D84.1 (K), D99.1 (K), D114.1 (K), D129.1 (K), D144.1 (K), D159.1 (K), D174.1 (K), D189.1 (K), D204.1 (K), D219.1 (K), R9.2
ROW_0: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), J1.15
ROW_1: D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), J1.14
ROW_2: D31.2 (A), D32.2 (A), D33.2 (A), D34.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D39.2 (A), D40.2 (A), D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), J1.13
ROW_3: D46.2 (A), D47.2 (A), D48.2 (A), D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), D56.2 (A), D57.2 (A), D58.2 (A), D59.2 (A), D60.2 (A), J1.12
ROW_4: D61.2 (A), D62.2 (A), D63.2 (A), D64.2 (A), D65.2 (A), D66.2 (A), D67.2 (A), D68.2 (A), D69.2 (A), D70.2 (A), D71.2 (A), D72.2 (A), D73.2 (A), D74.2 (A), D75.2 (A), J1.11
ROW_5: D76.2 (A), D77.2 (A), D78.2 (A), D79.2 (A), D80.2 (A), D81.2 (A), D82.2 (A), D83.2 (A), D84.2 (A), D85.2 (A), D86.2 (A), D87.2 (A), D88.2 (A), D89.2 (A), D90.2 (A), J1.10
ROW_6: D91.2 (A), D92.2 (A), D93.2 (A), D94.2 (A), D95.2 (A), D96.2 (A), D97.2 (A), D98.2 (A), D99.2 (A), D100.2 (A), D101.2 (A), D102.2 (A), D103.2 (A), D104.2 (A), D105.2 (A), J1.9
ROW_7: D106.2 (A), D107.2 (A), D108.2 (A), D109.2 (A), D110.2 (A), D111.2 (A), D112.2 (A), D113.2 (A), D114.2 (A), D115.2 (A), D116.2 (A), D117.2 (A), D118.2 (A), D119.2 (A), D120.2 (A), J1.1
ROW_8: D121.2 (A), D122.2 (A), D123.2 (A), D124.2 (A), D125.2 (A), D126.2 (A), D127.2 (A), D128.2 (A), D129.2 (A), D130.2 (A), D131.2 (A), D132.2 (A), D133.2 (A), D134.2 (A), D135.2 (A), J1.2
ROW_9: D136.2 (A), D137.2 (A), D138.2 (A), D139.2 (A), D140.2 (A), D141.2 (A), D142.2 (A), D143.2 (A), D144.2 (A), D145.2 (A), D146.2 (A), D147.2 (A), D148.2 (A), D149.2 (A), D150.2 (A), J1.3
ROW_10: D151.2 (A), D152.2 (A), D153.2 (A), D154.2 (A), D155.2 (A), D156.2 (A), D157.2 (A), D158.2 (A), D159.2 (A), D160.2 (A), D161.2 (A), D162.2 (A), D163.2 (A), D164.2 (A), D165.2 (A), J1.4
ROW_11: D166.2 (A), D167.2 (A), D168.2 (A), D169.2 (A), D170.2 (A), D171.2 (A), D172.2 (A), D173.2 (A), D174.2 (A), D175.2 (A), D176.2 (A), D177.2 (A), D178.2 (A), D179.2 (A), D180.2 (A), J1.5
ROW_12: D181.2 (A), D182.2 (A), D183.2 (A), D184.2 (A), D185.2 (A), D186.2 (A), D187.2 (A), D188.2 (A), D189.2 (A), D190.2 (A), D191.2 (A), D192.2 (A), D193.2 (A), D194.2 (A), D195.2 (A), J1.6
ROW_13: D196.2 (A), D197.2 (A), D198.2 (A), D199.2 (A), D200.2 (A), D201.2 (A), D202.2 (A), D203.2 (A), D204.2 (A), D205.2 (A), D206.2 (A), D207.2 (A), D208.2 (A), D209.2 (A), D210.2 (A), J1.7
ROW_14: D211.2 (A), D212.2 (A), D213.2 (A), D214.2 (A), D215.2 (A), D216.2 (A), D217.2 (A), D218.2 (A), D219.2 (A), D220.2 (A), D221.2 (A), D222.2 (A), D223.2 (A), D224.2 (A), D225.2 (A), J1.8

Board: 2 copper layers, 33.0 x 40.0 mm, 242 parts (0 on the bottom side), 45 nets.

## Commit log

2019-04-29 Initial import
2019-04-29 update logic board outline
2019-04-29 Reassign pins to avoid crossing
2019-04-29 Add power net and route matrix connections
2019-05-08 new concept
2019-05-08 add components
2019-08-25 rework for SAMD21
2019-08-26 Wire it up
2019-08-26 Wired it all up
2020-01-21 initial rework to atmega1284p
2020-03-15 erm, well, I did this ages ago so...
